# Repository rakuseirobot/Aquila-PCB

File README.md:

# Aquila-PCB
Aquilaの2019年度、2018年度、回路図及びボード図です。

Robocup Junior Rescue Maze Program

このリポジトリは2019年度のAquilaのメインプログラムです。

# Note

メイン基板のデータです。

/2018以下のAquila-2018-Under基板にセンサーを配線し、メイン基板に配線します。

# Link

[About robot](https://qiita.com/Shunk_/items/b6b5c49862ec9f9d852b)

[How to make RCJM](https://qiita.com/Shunk_/items/2ea0795d571d771d52ca)

[回路](https://github.com/rakuseirobot/Aquila-PCB)

[STM32-program](https://github.com/rakuseirobot/Aquila-2019)

[OpenMV](https://github.com/rakuseirobot/Aquila-OpenMV)

[設計図](https://github.com/rakuseirobot/Aquila-drawings)

[古いメインプログラム(ATxmega)](https://github.com/rakuseirobot/Aquila-Code-v3)

# Author

* Shun Kayaki

    Kyushu institute of Technology
    
    shun@guetan.dev

* Emile

# License

Copyright (c) 2019 Aquila
Released under the MIT license

## EAGLE design 2018/Aquila-2018-Under2.brd

Parts:
CN2: COLOR-ZH-M; B7B-ZR
I2C-R: XH-4; CON4
I2C-R1, I2C-R2: 4.7K; R0805
L1, L2, L3: PW-LED; CHIPLED_0805
LED-R, LED-R1, LED-R2: 330; R0805
M-SP, M-SP2: MAIN; AK500/2
MAINCON: ML26
MOTORDRIVER: ML14
MOTORDRIVER1: MA13-1
MV1, MV2, MV3: B7B-ZR
PAS1, PAS2, PAS3: 0.1u; C0805
PCA9547: PCA9547; SO24L
PING1, PING2, PING3, PING4, PING5, PING6: XH-3; CON3
RES-R: 4.7K; R0805
RO1, RO2: XH-3; CON3
SERMO1, SERMO2: FE04-W
SERMO-R1: 4.7k; EXB28V
SW-ADDR: 219-04; CTS-219-04
SW-R1, SW-R2, SW-R3: 4.7K; R0805
U-SP: 5566-04A
VL01, VL02, VL03, VL04, VL05, VL06: FE04-W
VL-R1, VL-R2, VL-R3: 4.7k; EXB28V

Connections:
+3V3: CN2.1, I2C-R.P$1 (1), I2C-R1.2, I2C-R2.2, L2.A, MOTORDRIVER1.11, PAS1.2, PAS2.2, PAS3.2, PCA9547.24 (VDD), RES-R.1, SERMO1.4, SERMO2.4, SERMO-R1.5 (2), SERMO-R1.6 (2), SERMO-R1.7 (2), SERMO-R1.8 (2), SW-ADDR.1, SW-ADDR.2, SW-ADDR.3, SW-ADDR.4, U-SP.4, VL01.4, VL02.4, VL03.4, VL04.4, VL05.4, VL06.4, VL-R1.5 (2), VL-R1.6 (2), VL-R1.7 (2), VL-R1.8 (2), VL-R2.5 (2), VL-R2.6 (2), VL-R2.7 (2), VL-R2.8 (2), VL-R3.5 (2), VL-R3.6 (2), VL-R3.7 (2), VL-R3.8 (2)
+5V: CN2.7, MV1.6, MV2.6, MV3.6, PING1.P$2 (2), PING2.P$2 (2), PING3.P$2 (2), PING4.P$2 (2), PING5.P$2 (2), PING6.P$2 (2), RO1.P$2 (2), RO2.P$2 (2), U-SP.3
+9V: M-SP.1, M-SP2.1, MOTORDRIVER1.12, U-SP.1
CK: CN2.5, MAINCON.6
DOUT: CN2.3, MAINCON.4
GATE: CN2.4, MAINCON.5
GND: CN2.2, I2C-R.P$2 (2), LED-R.1, LED-R1.1, LED-R2.1, M-SP.2, M-SP2.2, MOTORDRIVER.13, MOTORDRIVER1.13, MV1.7, MV2.7, MV3.7, PAS1.1, PAS2.1, PAS3.1, PCA9547.12 (GND), PING1.P$3 (3), PING2.P$3 (3), PING3.P$3 (3), PING4.P$3 (3), PING5.P$3 (3), PING6.P$3 (3), RO1.P$1 (1), RO2.P$1 (1), SERMO1.3, SERMO2.3, SW-R1.1, SW-R2.1, SW-R3.1, U-SP.2, VL01.3, VL02.3, VL03.3, VL04.3, VL05.3, VL06.3
M1CS: MOTORDRIVER.6, MOTORDRIVER1.6
M1EN: MOTORDRIVER.10, MOTORDRIVER1.10
M1INA: MOTORDRIVER.9, MOTORDRIVER1.9
M1INB: MOTORDRIVER.8, MOTORDRIVER1.8
M1PWM: MOTORDRIVER.7, MOTORDRIVER1.7
M2CS: MOTORDRIVER.1, MOTORDRIVER1.1
M2EN: MOTORDRIVER.5, MOTORDRIVER1.5
M2INA: MOTORDRIVER.4, MOTORDRIVER1.4
M2INB: MOTORDRIVER.3, MOTORDRIVER1.3
M2PWM: MOTORDRIVER.2, MOTORDRIVER1.2
MISOD: MAINCON.15, MV1.3, MV2.3, MV3.3
MOSID: MAINCON.16, MV1.2, MV2.2, MV3.2
MV1: MAINCON.19, MV1.1
MV2: MAINCON.18, MV2.1
MV3: MAINCON.17, MV3.1
MVS1: MAINCON.1, MV1.5
MVS2: MAINCON.2, MV2.5
MVS3: MAINCON.3, MV3.5
unnamed: PCA9547.1 (A0), SW-ADDR.5, SW-R3.2
unnamed: PCA9547.2 (A1), SW-ADDR.6, SW-R2.2
unnamed: PCA9547.21 (A2), SW-ADDR.7, SW-R1.2
unnamed: L2.C, LED-R.2
unnamed: PCA9547.3 (RESET), RES-R.2
unnamed: L1.C, LED-R1.2
unnamed: L1.A, MAINCON.24
unnamed: L3.C, LED-R2.2
unnamed: L3.A, MOTORDRIVER.11
PING1: MAINCON.13, PING1.P$1 (1)
PING2: MAINCON.12, PING2.P$1 (1)
PING3: MAINCON.11, PING3.P$1 (1)
PING4: MAINCON.10, PING4.P$1 (1)
PING5: MAINCON.9, PING5.P$1 (1)
PING6: MAINCON.8, PING6.P$1 (1)
RANGE: CN2.6, MAINCON.7
RO1: MAINCON.25, RO1.P$3 (3)
RO2: MAINCON.26, RO2.P$3 (3)
SCKD: MAINCON.14, MV1.4, MV2.4, MV3.4
SCL0: PCA9547.11 (SC3), SERMO2.2, SERMO-R1.4 (1)
SCL1: PCA9547.7 (SC1), VL06.2, VL-R1.4 (1)
SCL2: PCA9547.5 (SC0), VL04.2, VL-R1.2 (1)
SCL3: PCA9547.14 (SC4), VL03.2, VL-R2.2 (1)
SCL4: PCA9547.18 (SC6), SERMO1.2, VL-R3.2 (1)
SCL5: PCA9547.16 (SC5), VL02.2, VL-R2.4 (1)
SCL6: PCA9547.9 (SC2), SERMO-R1.2 (1), VL05.2
SCL7: PCA9547.20 (SC7), VL01.2, VL-R3.4 (1)
SCL-D: I2C-R.P$4 (4), I2C-R1.1, MAINCON.20, PCA9547.22 (SCL)
SDA0: PCA9547.10 (SD3), SERMO2.1, SERMO-R1.3 (1)
SDA1: PCA9547.6 (SD1), VL06.1, VL-R1.3 (1)
SDA2: PCA9547.4 (SD0), VL04.1, VL-R1.1
SDA3: PCA9547.13 (SD4), VL03.1, VL-R2.1
SDA4: PCA9547.17 (SD6), SERMO1.1, VL-R3.1
SDA5: PCA9547.15 (SD5), VL02.1, VL-R2.3 (1)
SDA6: PCA9547.8 (SD2), SERMO-R1.1, VL05.1
SDA7: PCA9547.19 (SD7), VL01.1, VL-R3.3 (1)
SDA-D: I2C-R.P$3 (3), I2C-R2.1, MAINCON.21, PCA9547.23 (SDA)

Board: 2 copper layers, 150.0 x 194.7 mm, 48 parts (6 on the bottom side), 62 nets.

## EAGLE design 2018/TEPIAmainboard.brd

Parts:
3.3C1, 3.3C6, 5C11, 5C16: 100u; E2,5-6
3.3C2, 3.3C3, 3.3C4, 3.3C5, 5C12, 5C13, 5C14, 5C15: 0.1u; C0805
3.3V-REGU, 5V-REGU: 78XXS
FALLING: MA04-1
FT232-R1: 4.7K; R0805
FT232-R2: 10K; R0805
FT232-R3: 1K; R0805
FT232-R4, FT232-R5: 330; R0805
FT232-R6, FT232-R7: 23; R0805
FT232USBCON: Wrie-USB; 32005-201
FT-POWERLED: LEDCHIPLED_0805; CHIPLED_0805
GND-CHK, GND-CHK1: 2,15/1,0
GNSS-SP1, GNSS-SP2: XH-2; CON2
GNSSSPI: MA04-1
GNSSUART: PINHD-1X2; 1X02
IC5: FT232RL; SSOP28
IIC1, IIC2, IIC3, IIC4: XH-4; CON4
IIC-UP1, IIC-UP2: 1K; R0805
IIC_D-R, IIC_D-R2: 4.7K; R0805
INTUART: MA03-1
JTAG: 20021221-00010C4LF
K, K0, K1, K2, K3, K4, K5, K6: 4.7K; R0805
KK1, KK2: D01PA
L1: RXDLED; CHIPLED_0805
L2: TXDLED; CHIPLED_0805
L6: TESTLED; CHIPLED_0805
L6480: MA05-2
LCD: MA09-1
LCD-I2C: LCD-I2C; MA05-1
M1-R1, M2-R1, M2-R2: 4.7K; R0805
MEGA1, MEGA2: MEGA8-AI; TQFP32-08
MEGA1-C1, MEGA2-C1: 0.1u; C0805
MOTOR-SUPPLY: MOTOR; AK500/2
MOTOR-SW: 320-916
MOTORDRIVER: MA13-1
MPU9250: MA10-1
PAD2: SMD5; SMD2,54-5,08
PING0, PING1, PING2, PING3, PING4: MA03-1
POWER-LED: LEDCHIPLED_0805; CHIPLED_0805
POWER-LEDR: 1K; R0805
Q1, Q2: 20MHz; CSTLS_X
Q3: IRF9530; TO220BV
RESET-MEGA1: R-2; DTS-6
RESET-MEGA2: R-1; DTS-6
RESET-XMEGA: DTS-6
RO1, RO2: XH-3; CON3
S1: DIP08S
SPI4, SPI5, SPI6, SPI7: MA05-1
SPI-SW1: DIP03YL
SS-1, SS-2, SS-3: 10K; R0805
SUOPPLY-SW1: XH-3; CON3
SUPPLY, SUPPLY3.3V, SUPPLY5V: MAIN; AK500/2
SV3: ML6
SW6, SW7: XH-2; CON2
SW6-R, SW7-R: 4.7K; R0805
TENKEY: MA08-1
TEST-R: 330; R0805
U1: ATXMEGA128A1U-AU; TQFP-100A-100
VOL-LED: XH-2; CON2
VOLTAGE-METER: XH-2; CON2
X1: DCJACK-MJ179P; MJ-179P
X-R1: 4.7K; R0805
XMEGA-C1: 0.1u; C0805

Connections:
+3V3: 3.3C4.1, 3.3C5.1, 3.3C6.+, 3.3V-REGU.OUT, GNSS-SP1.P$1 (1), GNSS-SP2.P$1 (1), IIC1.P$2 (2), IIC2.P$2 (2), IIC3.P$2 (2), IIC4.P$2 (2), IIC-UP1.1, IIC-UP2.1, IIC_D-R.2, IIC_D-R2.2, JTAG.4, L6480.4, LCD.9, LCD-I2C.1, M1-R1.2, M2-R1.2, MEGA1.4 (VCC), MEGA1.6 (VCC), MEGA1.18 (AVCC), MEGA1-C1.2, MEGA2.4 (VCC), MEGA2.6 (VCC), MEGA2.18 (AVCC), MEGA2-C1.1, MOTORDRIVER.11, MPU9250.1, MPU9250.2, SS-1.1, SS-2.1, SS-3.2, SUPPLY3.3V.1, SW6.P$1 (1), SW7.P$1 (1), U1.4 (AVCC), U1.14 (VCC), U1.24 (VCC), U1.34 (VCC), U1.44 (VCC), U1.54 (VCC), U1.64 (VCC), U1.74 (VCC), U1.83 (VCC), U1.94 (AVCC), X-R1.2, XMEGA-C1.1
+5V: 5C14.1, 5C15.1, 5C16.+, 5V-REGU.OUT, PING0.2, PING1.2, PING2.2, PING3.2, PING4.2, POWER-LEDR.2, RO1.P$2 (2), RO2.P$2 (2), SUPPLY5V.1
+9V: 3.3C1.+, 3.3C2.1, 3.3C3.1, 3.3V-REGU.IN, 5C11.+, 5C12.1, 5C13.1, 5V-REGU.IN, MOTOR-SW.2, Q3.D, VOL-LED.P$1 (1), VOLTAGE-METER.P$1 (1)
CS_1: MPU9250.6, U1.65 (PJ0)
CS_2: L6480.7, U1.66 (PJ1)
CS_3: GNSSSPI.1, U1.67 (PJ2)
CS_4: SPI4.4, U1.68 (PJ3)
CS_5: SPI5.4, U1.69 (PJ4)
CS_6: SPI6.4, U1.70 (PJ5)
CS_7: SPI7.4, U1.71 (PJ6)
D_/RST: LCD.6, U1.48 (PF3)
D_RS: LCD.5
FT232-RXD: IC5.5 (RXD), L1.A, S1.10 (2), S1.12 (2), S1.14 (2)
FT232-TXD: IC5.1 (TXD), L2.A, S1.9 (2), S1.11 (2), S1.13 (2)
FT-POWERLED: FT232-R3.2, FT-POWERLED.C
FT-RESET: IC5.6 (!RI), S1.15 (2), S1.16 (2)
GND: 3.3C1.-, 3.3C2.2, 3.3C3.2, 3.3C4.2, 3.3C5.2, 3.3C6.-, 3.3V-REGU.GND, 5C11.-, 5C12.2, 5C13.2, 5C14.2, 5C15.2, 5C16.-, 5V-REGU.GND, FALLING.4, FT232-R2.1, FT232-R3.1, FT232-R4.1, FT232-R5.1, FT232USBCON.5, FT232USBCON.M1 (S1), FT232USBCON.M2 (S2), FT232USBCON.M3 (S3), FT232USBCON.M4 (S4), GND-CHK.1, GND-CHK1.1, GNSS-SP1.P$2 (2), GNSS-SP2.P$2 (2), IC5.7 (GND), IC5.18 (GND), IC5.21 (GND), IC5.25 (GND), IC5.26 (TEST), IIC1.P$1 (1), IIC2.P$1 (1), IIC3.P$1 (1), IIC4.P$1 (1), INTUART.3, JTAG.2, JTAG.10, K.1, K0.1, K1.1, K2.1, K3.1, K4.1, K5.1, K6.1, L6480.8, LCD.2, LCD.8, LCD-I2C.5, MEGA1.3 (GND), MEGA1.5 (GND), MEGA1.21 (GND), MEGA1-C1.1, MEGA2.3 (GND), MEGA2.5 (GND), MEGA2.21 (GND), MEGA2-C1.2, MOTOR-SUPPLY.2, MOTORDRIVER.13, MPU9250.10, PAD2.1, PING0.1, PING1.1, PING2.1, PING3.1, PING4.1, POWER-LED.C, Q1.2 (VSS), Q2.2 (VSS), RESET-MEGA1.3, RESET-MEGA1.4, RESET-MEGA2.3, RESET-MEGA2.4, RESET-XMEGA.3, RESET-XMEGA.4, RO1.P$1 (1), RO2.P$1 (1)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
INA: FALLING.2, U1.85 (PQ0)
INB: FALLING.3, U1.86 (PQ1)
L6480_STBY: L6480.10, U1.36 (PE1)
M1CS: MEGA2.25 (PC2(ADC2)), MOTORDRIVER.6, SS-2.2
M1EN: MEGA2.28 (PC5(ADC5/SCL)), MOTORDRIVER.10
M1INA: MEGA2.27 (PC4(ADC4/SDA)), MOTORDRIVER.9
M1INB: MEGA2.26 (PC3(ADC3)), MOTORDRIVER.8
M1PWM: MEGA2.10 (PD6(AIN0)), MOTORDRIVER.7
M2CS: MEGA1.25 (PC2(ADC2)), MOTORDRIVER.1, SS-1.2
M2EN: MEGA1.28 (PC5(ADC5/SCL)), MOTORDRIVER.5
M2INA: MEGA1.27 (PC4(ADC4/SDA)), MOTORDRIVER.4
M2INB: MEGA1.26 (PC3(ADC3)), MOTORDRIVER.3
M2PWM: MEGA1.10 (PD6(AIN0)), MOTORDRIVER.2
MISO: IC5.11 (!CTS), MEGA1.16 (PB4(MISO)), MEGA2.16 (PB4(MISO)), SPI-SW1.2
MISO-X: SPI-SW1.5, U1.21 (PC6)
MISO_E: L6480.3, MPU9250.5, U1.41 (PE6)
MISO_F: GNSSSPI.3, U1.51 (PF6)
MISO_U: LCD.1, SPI4.2, SPI5.2, SPI6.2, SPI7.2, U1.31 (PD6)
MOSI: IC5.10 (!DCD), MEGA1.15 (PB3(MOSI/OC2)), MEGA2.15 (PB3(MOSI/OC2)), SPI-SW1.1
MOSI-X: SPI-SW1.6, U1.20 (PC5)
MOSI_E: L6480.6, MPU9250.4, U1.40 (PE5)
MOSI_F: GNSSSPI.4, U1.50 (PF5)
MOSI_U: LCD.4, SPI4.1, SPI5.1, SPI6.1, SPI7.1, U1.30 (PD5)
M_PWM: FALLING.1, U1.35 (PE0)
unnamed: MEGA2.32 (PD2(INT0)), RO1.P$3 (3)
unnamed: POWER-LED.A, POWER-LEDR.1
unnamed: MEGA1.32 (PD2(INT0)), RO2.P$3 (3)
unnamed: M2-R2.2, Q3.S, SUPPLY.1, X1.1
unnamed: SV3.1, U1.89 (PDI)
unnamed: FT232-R6.1, IC5.15 (USBDP)
unnamed: MEGA1.7 (PB6(XTAL1/TOSC1)), Q1.1
unnamed: MEGA1.8 (PB7(XTAL2/TOSC2)), Q1.3
unnamed: FT232-R6.2, FT232USBCON.3
unnamed: FT232-R7.1, IC5.16 (USBDM)
unnamed: L6.A, U1.98 (PA3)
unnamed: L6.C, TEST-R.2
unnamed: MEGA2.7 (PB6(XTAL1/TOSC1)), Q2.1
unnamed: FT232-R7.2, FT232USBCON.2
unnamed: MEGA2.8 (PB7(XTAL2/TOSC2)), Q2.3
unnamed: FT232-R1.2, FT232USBCON.1, FT-POWERLED.A, IC5.20 (VCC)
unnamed: FT232-R1.1, FT232-R2.2, IC5.19 (!RESET)
unnamed: FT232-R4.2, L1.C
unnamed: FT232-R5.2, L2.C
unnamed: M2-R2.1, Q3.G, SUOPPLY-SW1.P$1 (1)
unnamed: IC5.4 (VCCIO), IC5.17 (3V3OUT)
unnamed: PING0.3, U1.55 (PH0)
unnamed: MOTOR-SUPPLY.1, MOTOR-SW.3 (S)
PH1: PING1.3, U1.56 (PH1)
PH2: PING2.3, U1.57 (PH2)
PH3: PING3.3, U1.58 (PH3)
PH4: PING4.3, U1.59 (PH4)
PH6: SW6.P$2 (2), SW6-R.2, U1.61 (PH6)
PH7: SW7.P$2 (2), SW7-R.2, U1.62 (PH7)
PK0: K0.2, TENKEY.8, U1.75 (PK0)
PK1: K1.2, TENKEY.7, U1.76 (PK1)
PK2: K2.2, TENKEY.6, U1.77 (PK2)
PK3: K3.2, TENKEY.5, U1.78 (PK3)
PK4: K4.2, TENKEY.4, U1.79 (PK4)
PK5: K5.2, TENKEY.3, U1.80 (PK5)
PK6: K6.2, TENKEY.2, U1.81 (PK6)
PK7: K.2, TENKEY.1, U1.82 (PK7)
RESET-M1: M1-R1.1, MEGA2.29 (PC6(/RESET)), RESET-MEGA2.1, RESET-MEGA2.2, S1.1
RESET-M2: M2-R1.1, MEGA1.29 (PC6(/RESET)), RESET-MEGA1.1, RESET-MEGA1.2, S1.2 (1)
RX0: INTUART.2, U1.37 (PE2)
RXD0_1: GNSSUART.2, U1.28 (PD3)
RXDM1: MEGA2.30 (PD0(RXD)), S1.6 (1)
RXDM2: MEGA1.30 (PD0(RXD)), S1.8 (1)
RXDX1: S1.4 (1), U1.17 (PC2)
SCK: IC5.9 (!DSR), MEGA1.17 (PB5(SCK)), MEGA2.17 (PB5(SCK)), SPI-SW1.3
SCK-X: SPI-SW1.4, U1.22 (PC7)
SCK_E: L6480.5, MPU9250.3, U1.42 (PE7)
SCK_F: GNSSSPI.2, U1.52 (PF7)
SCK_U: LCD.3, SPI4.3, SPI5.3, SPI6.3, SPI7.3, U1.32 (PD7)
SCL_D: IIC1.P$3 (3), IIC2.P$3 (3), IIC3.P$3 (3), IIC4.P$3 (3), IIC_D-R2.1, U1.26 (PD1)
SCL_F: IIC-UP2.2, LCD-I2C.3, U1.46 (PF1)
SDA_D: IIC1.P$4 (4), IIC2.P$4 (4), IIC3.P$4 (4), IIC4.P$4 (4), IIC_D-R.1, U1.25 (PD0)
SDA_F: IIC-UP1.2, LCD-I2C.4, U1.45 (PF0)
SS1: MEGA1.14 (PB2(SS/OC1B)), U1.15 (PC0)
SS2: MEGA2.14 (PB2(SS/OC1B)), U1.16 (PC1)
SS_F: U1.49 (PF4)
SS_U: LCD.7, SS-3.1, U1.29 (PD4)
TCK: JTAG.1, U1.11 (PB6)
TDI: JTAG.9, U1.10 (PB5)
TDO: JTAG.3, U1.12 (PB7)
TMS: JTAG.5, U1.9 (PB4)
TX0: INTUART.1, U1.38 (PE3)
TXD0_1: GNSSUART.1, U1.27 (PD2)
TXDM1: MEGA2.31 (PD1(TXD)), S1.5 (1)
TXDM2: MEGA1.31 (PD1(TXD)), S1.7 (1)
TXDX1: S1.3 (1), U1.18 (PC3)
X-RESET: JTAG.6, LCD-I2C.2, RESET-XMEGA.1, RESET-XMEGA.2, SV3.5, U1.90 (!RESET!/PDI), X-R1.1

Notes on the sheet:
FT232RL
MOTOR-AREA
LCD
SWITCHING-SWITCH
Supply
FT232接続のUSARTを USARTD1からUSARTC0に変更
MPU9250
L6480
外出しUART
カラーLCD
GNSS-UART
GNSS-SPI
超音波
JTAG
超音波予備
電源ピン (予備電源含)
UI-SW
L6470_STBYをPJ7からPE1に変更
