# Repository rakuseirobot/Aquila-PCB (continued)

## EAGLE design Aquila-2019-ex.brd

Schematic: Aquila-2019-ex.sch

Parts:
3.3C1, 5C1, 9C1: 100u; D/7343-31R
3.3C2, 5C2, 9C2: 0.1u; C0805
3.3REG, 5VREG: OKL-T_6-W12N-C; OKL-T/3-W5
8MHZ: P-08669_HUSG-12.000-20; HC49U-V
BOOT0-STM: DTS-6
C1, C3: 22uF25V; C2012
C2, C4: 10uF10V; C2012
C5, C6: 22pF; C1608
CHECKLED: OSTA71A1D-A
CON1, CON2: XH-4; CON4
DIO0-JP: BOOT0; SJ
DIO1-JP: NRST; SJ
ERROR1-R, ERROR2-R: 330; R0805
FET1, FET2: IRF740; TO220BV
FET1-R1, FET2-R1: 100; R0805
FET1-R2, FET2-R2: 4.7K; R0805
GND-CH: GND; SMD2,54-5,08
GND-CHK, GND-CHK1: GND; 2,15/1,0
I2C-R1, I2C-R2: 4.7k; R0805
IC1: STM32F429VGT; LQFP100
IC2: ULN2003AN; DIL16
IC3: AT24CP; DIL08
IC4: AE-AQM0802
IIC-R: XH-4; CON4
INDILED1, INDILED2, INDILED3, INDILED4: 330; R0805
J1: XH-5; CON5
JY901: XH-4; CON4
L3: E1; LED5MM
L4: E2; LED5MM
LED1, LED2: OSL10564-CD4026B-R; DIPS1524W50P254L1260H800Q10N
LEDSP, LEDSP2: MAIN; AK500/2
M-SW: TL36PO; TL3XPO
MAIN-SPL: XH-2; CON2
MAINSW2: MAIN; MA03-1
MOTORDRIVER: MDCON; ML14
Q3, Q4, Q5: IRF9530; TO220BV
R1, R2: 1.2k; 0204/7
R-B: ?; R0805
R-G: ?; R0805
R-R: ?; R0805
RESET-STM: DTS-6
S1, S3: SKRPACE010; SW_SKRPACE010
S2: VM; M251
SG1: F/EE17P
SL-R1: 1K; R0805
SP-LED: LEDCHIPLED_0805; CHIPLED_0805
SP-R1, SP-R3: 1.2k; R0805
SP-R2, SP-R4: 20K; R0805
SP-R5, SP-R6: 4.7K; R0805
SP-RC1, SP-RC2: 20k; RTRIM3296W
SP-SW2: 219-02; CTS-219-02
SPI-LCD: FE09-1; FE09
SPI-R: XH-6; CON6
SRAM-R1: 4.7K; R0805
SRAM-R2: 10k; R0805
STEPINDI1, STEPINDI2, STEPINDI3, STEPINDI4: LED; CHIPLED_0805
STM-C1, STM-C2, STM-C3, STM-C4, STM-C5, STM-C6: 0.1u; C0805
STM-R1, STM-R2: 4.7K; R0805
SUOPPLY-SW2: XH-3; CON3
SUPPLY3.3V, SUPPLY5V, SUPPLY9: MAIN; AK500/2
SV1: MA06-1
TESTSW-R1, TESTSW-R2, TESTSW-R3: 4.7K; R0805
TO-UNDER: ML26
TOUCH1, TOUCH2: XH-3; CON3
TW-SP: XH-2; CON2
TWILITE: C2; MA05-1
U2: 23K256-I/SN; SOIC127P600X175-8N
U$2: 5566-04A
VOLTAGE-METER1, VOLTAGE-METER2: XH-2; CON2
X2: DCJACK-MJ179P; MJ-179P
X-R2: 4.7K; R0805
XB1: XBEE-PRO
XBEE-RST: 4.7K; R0805
XMEGA-TEST1: SW1; DTS-6
XMEGA-TEST2: SW2; DTS-6
XMEGA-TEST3: SW3; DTS-6

Connections:
+3V3: 3.3C1.+, 3.3C2.1, 3.3REG.4 (VOUT), 3.3REG.5 (SENSE), BOOT0-STM.1, BOOT0-STM.2, C4.1, CHECKLED.ANODE, I2C-R1.2, I2C-R2.2, IC1.6 (VBAT), IC1.11 (VDD), IC1.19 (VDD), IC1.21 (VREF+), IC1.22 (VDDA), IC1.28 (VDD), IC1.50 (VDD), IC1.75 (VDD), IC1.100 (VDD), IC3.1 (A0), IC3.2 (A1), IC3.3 (A2), IC3.8 (VCC), IC4.VDD, IIC-R.P$3 (3), JY901.P$4 (4), LED1.1 (VDD), LED2.1 (VDD), MOTORDRIVER.11, R2.1, S2.1 (O), S3.3, S3.4, SPI-LCD.1, SPI-R.P$1 (1), SRAM-R1.2, SRAM-R2.2, STM-C1.2, STM-C2.2, STM-C3.2, STM-C4.2, STM-R1.2, SUPPLY3.3V.1, SV1.1, TO-UNDER.24, TOUCH1.P$2 (2), TOUCH2.P$2 (2), TW-SP.P$2 (2), U2.8 (VCC), U$2.4, XB1.1 (VCC), XB1.14 (VREF), XBEE-RST.2, XMEGA-TEST1.1, XMEGA-TEST1.2, XMEGA-TEST2.1, XMEGA-TEST2.2, XMEGA-TEST3.1, XMEGA-TEST3.2
+5V: 5C1.+, 5C2.1, 5VREG.4 (VOUT), 5VREG.5 (SENSE), C2.1, CON1.P$3 (3), CON2.P$3 (3), IC2.9 (CD+), INDILED1.2, INDILED2.2, INDILED3.2, INDILED4.2, J1.P$1 (1), R1.1, S2.3 (S), SP-LED.A, SUPPLY5V.1, U$2.3
+9V: 3.3REG.2 (VIN), 5VREG.2 (VIN), 9C1.+, 9C2.1, C1.1, C3.1, LEDSP.1, LEDSP2.1, MAIN-SPL.P$1 (1), Q4.S, Q5.D, SP-R2.2, SP-R4.2, SP-R5.2, VOLTAGE-METER1.P$1 (1)
BUZZER: IC1.77 (PA15), SG1.1, X-R2.2
CK: IC1.88 (PD7), TO-UNDER.6
CL: IC1.65 (PC8), LED1.9 (CL)
DIO0: BOOT0-STM.3, BOOT0-STM.4, DIO0-JP.1, IC1.94 (BOOT0), STM-R2.1
DIO1: DIO1-JP.1, IC1.14 (NRST), IC4.RESET, RESET-STM.3, RESET-STM.4, STM-R1.1, SV1.5
DOUT: IC1.90 (PB4), TO-UNDER.4
DP1: IC1.69 (PA10), LED1.5 (DP)
DP2: IC1.70 (PA11), LED2.5 (DP)
E1: IC1.35 (PB0), L3.A
E2: IC1.36 (PB1), L4.A
FET1: FET1-R1.2, IC1.95 (PB8)
FET2: FET2-R1.2, IC1.96 (PB9)
FLED-BLUE: IC1.7 (PC13), R-B.1
FLED-GREEN: IC1.8 (PC14), R-G.1
FLED-RED: IC1.9 (PC15), R-R.1
GATE: IC1.89 (PB3), TO-UNDER.5
GND: 3.3C1.-, 3.3C2.2, 3.3REG.3 (GND_1), 3.3REG.7 (GND_2), 5C1.-, 5C2.2, 5VREG.3 (GND_1), 5VREG.7 (GND_2), 9C1.-, 9C2.2, C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, CON1.P$4 (4), CON2.P$4 (4), ERROR1-R.1, ERROR2-R.1, FET1.S, FET1-R2.1, FET2.S, FET2-R2.1, GND-CH.1, GND-CHK.1, GND-CHK1.1, IC1.10 (VSS), IC1.20 (VSSA), IC1.27 (VSS), IC1.74 (VSS), IC1.99 (VSS), IC2.5 (I5), IC2.6 (I6), IC2.7 (I7), IC2.8 (GND), IC3.4 (GND), IC3.7 (WP), IC4.GND, IIC-R.P$4 (4), JY901.P$1 (1), LED1.8 (GND), LED2.8 (GND), M-SW.3 (S), MAIN-SPL.P$2 (2), MAINSW2.2, MOTORDRIVER.13, Q3.G, R1.2, R2.2, RESET-STM.1, RESET-STM.2, S1.1, S1.2, SG1.2, SL-R1.1, SP-R1.1, SP-R3.1, SP-SW2.3, SP-SW2.4, SPI-LCD.2, SPI-LCD.8, SPI-R.P$6 (6), STM-C1.1, STM-C2.1, STM-C3.1, STM-C4.1, STM-C5.2, STM-C6.2, STM-R2.2, SUOPPLY-SW2.P$2 (2), SUPPLY3.3V.2, SUPPLY5V.2, SUPPLY9.2, SV1.3, TESTSW-R1.1, TESTSW-R2.1, TESTSW-R3.1, TOUCH1.P$3 (3), TOUCH2.P$3 (3)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
LCD-CS: IC1.53 (PB14), SPI-LCD.3
LCD-RST: IC1.54 (PB15), SPI-LCD.4
LED-RST: IC1.71 (PA12), LED1.2 (RS), LED2.2 (RS), S3.1, S3.2
M1CS: IC1.41 (PE10), MOTORDRIVER.6
M1EN: IC1.38 (PE7), MOTORDRIVER.10
M1INA: IC1.37 (PB2), MOTORDRIVER.9
M1INB: IC1.39 (PE8), MOTORDRIVER.8
M1PWM: IC1.40 (PE9), MOTORDRIVER.7
M2CS: IC1.46 (PE15), MOTORDRIVER.1
M2EN: IC1.43 (PE12), MOTORDRIVER.5
M2INA: IC1.44 (PE13), MOTORDRIVER.4
M2INB: IC1.45 (PE14), MOTORDRIVER.3
M2PWM: IC1.42 (PE11), MOTORDRIVER.2
MISOD: IC1.17 (PC2), TO-UNDER.15
MISOF: IC1.31 (PA6), SPI-LCD.9, SPI-R.P$4 (4), U2.2 (SO)
MOSID: IC1.18 (PC3), TO-UNDER.16
MOSIF: IC1.32 (PA7), SPI-LCD.6, SPI-R.P$3 (3), U2.5 (SI)
MR1A: CON1.P$2 (2), IC1.23 (PA0)
MR1B: CON1.P$1 (1), IC1.24 (PA1)
MR2A: CON2.P$2 (2), IC1.63 (PC6)
MR2B: CON2.P$1 (1), IC1.64 (PC7)
MV1: IC1.78 (PC10), TO-UNDER.19
MV2: IC1.79 (PC11), TO-UNDER.18
MV3: IC1.80 (PC12), TO-UNDER.17
MVS1: IC1.3 (PE4), TO-UNDER.1
MVS2: IC1.2 (PE3), TO-UNDER.2
MVS3: IC1.1 (PE2), TO-UNDER.3
unnamed: IC1.62 (PD15), IC2.4 (I4)
unnamed: DIO1-JP.2, XB1.19 (AD1/DIO1)
unnamed: SP-R1.2, SP-RC1.1 (A), SP-RC1.2 (S)
unnamed: IC1.61 (PD14), IC2.3 (I3)
unnamed: Q3.S, Q5.S, SP-R6.2
unnamed: Q4.D, U$2.1
unnamed: SP-R3.2, SP-RC2.1 (A), SP-RC2.2 (S)
unnamed: M-SW.2, Q4.G
unnamed: 5VREG.6 (TRIM), SP-RC1.3 (E)
unnamed: M-SW.1 (O), SP-R5.1
unnamed: S2.2, VOLTAGE-METER2.P$1 (1)
unnamed: IC1.60 (PD13), IC2.2 (I2)
unnamed: 3.3REG.6 (TRIM), SP-RC2.3 (E)
unnamed: IC1.59 (PD12), IC2.1 (I1)
unnamed: 3.3REG.1 (ON/OFF), SP-R4.1, SP-SW2.2
unnamed: IC2.16 (O1), J1.P$2 (2), STEPINDI1.C
unnamed: IC2.15 (O2), J1.P$3 (3), STEPINDI2.C
unnamed: IC2.14 (O3), J1.P$4 (4), STEPINDI3.C
unnamed: IC2.13 (O4), J1.P$5 (5), STEPINDI4.C
unnamed: INDILED4.1, STEPINDI4.A
unnamed: INDILED3.1, STEPINDI3.A
unnamed: INDILED2.1, STEPINDI2.A
unnamed: INDILED1.1, STEPINDI1.A
unnamed: SL-R1.2, SP-LED.C
unnamed: 8MHZ.1, C6.2, IC1.13 (OSC_OUT)
unnamed: 5VREG.1 (ON/OFF), SP-R2.1, SP-SW2.1
unnamed: 8MHZ.2, C5.2, IC1.12 (OSC_IN)
unnamed: FET1.G, FET1-R1.1, FET1-R2.2
unnamed: FET1.D, LEDSP.2
unnamed: FET2.G, FET2-R1.1, FET2-R2.2
unnamed: FET2.D, LEDSP2.2
unnamed: IC1.73 (VCAP2), STM-C5.1
unnamed: IC1.49 (VCAP1), STM-C6.1
unnamed: Q3.D, SUPPLY9.1, X2.1
unnamed: DIO0-JP.2, XB1.20 (AD0/DIO0)
unnamed: MAINSW2.1, Q5.G, SP-R6.1, SUOPPLY-SW2.P$1 (1)
unnamed: S1.3, S1.4, XB1.5 (!RESET), XBEE-RST.1
unnamed: ERROR1-R.2, L3.K (C)
unnamed: ERROR2-R.2, L4.K (C)
unnamed: LED1.4 (CO), LED2.9 (CL)
unnamed: CHECKLED.RED, R-R.2
unnamed: CHECKLED.GREEN, R-G.2
unnamed: CHECKLED.BLUE, R-B.2
PING1: IC1.81 (PD0), TO-UNDER.13
PING2: IC1.82 (PD1), TO-UNDER.12
PING3: IC1.83 (PD2), TO-UNDER.11
PING4: IC1.84 (PD3), TO-UNDER.10
PING5: IC1.85 (PD4), TO-UNDER.9
PING6: IC1.86 (PD5), TO-UNDER.8
RAM-CS: IC1.4 (PE5), SRAM-R1.1, U2.1 (~CS)
RAM-HOLD: IC1.29 (PA4), SRAM-R2.1, U2.7 (~HOLD)
RANGE: IC1.87 (PD6), TO-UNDER.7
RO1: TO-UNDER.25
RO2: TO-UNDER.26
SCKD: IC1.52 (PB13), TO-UNDER.14
SCKF: IC1.30 (PA5), SPI-LCD.7, SPI-R.P$2 (2), U2.6 (SCK)
SCL-C: I2C-R1.1, IC1.47 (PB10), IC3.6 (SCL), IIC-R.P$1 (1), JY901.P$2 (2)
SCL-D: IC1.67 (PA8), IC4.SCL, TO-UNDER.20
SDA-C: I2C-R2.1, IC1.48 (PB11), IC3.5 (SDA), IIC-R.P$2 (2), JY901.P$3 (3)
SDA-D: IC1.66 (PC9), IC4.SDA, TO-UNDER.21
SS-R: IC1.5 (PE6), SPI-R.P$5 (5)
SW1: IC1.55 (PD8), TESTSW-R1.2, XMEGA-TEST1.3, XMEGA-TEST1.4
SW2: IC1.56 (PD9), TESTSW-R2.2, XMEGA-TEST2.3, XMEGA-TEST2.4
SW3: IC1.57 (PD10), TESTSW-R3.2, XMEGA-TEST3.3, XMEGA-TEST3.4
SWCLK: IC1.76 (PA14), SV1.2
SWDIO: IC1.72 (PA13), SV1.4
TOUCH1: IC1.15 (PC0), TOUCH1.P$1 (1)
TOUCH2: IC1.16 (PC1), TOUCH2.P$1 (1)
USART1-RX: IC1.93 (PB7), XB1.2 (DOUT)
USART1-TX: IC1.92 (PB6), XB1.3 (DIN/!CONFIG)
USART2RX: IC1.26 (PA3), TWILITE.4
USART2TX: IC1.25 (PA2), TWILITE.2

Notes on the sheet:
CHECK-LED
Xmega-TESTSW
TOUCH
Buzzer
ERROR-LEDs
電源ピン (予備電源含)

Board: 2 copper layers, 99.0 x 98.7 mm, 123 parts (26 on the bottom side), 117 nets.

Other parts of the board:
U$1: EAGLE-PLC-12MM
U$3: I2C
U$4: TONNE_10.00
U$5: LOGO

## EAGLE design 2018/Aquila-2018-Color&MV.brd

Board: 2 copper layers, 77.0 x 88.0 mm, 96 parts (24 on the bottom side), 136 nets.

Parts:
CN5, CN6, CN7, CN8, CN9, CN10, CN11, CN12: COLOR-ZH-M; B7B-ZR
L1, L3, L5, L7: SP-L; CHIPLED_0805
L2, L4, L6, L8: LED; CHIPLED_0805
LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: GM1WA55311A
LED-R, LED-R1, LED-R2, LED-R3: 330; R0805
MV1, MV2, MV3, MV4: B7B-ZR
R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36: 330; R0805
S1, S2, S3, S4: M251
SERMO, SERMO1, SERMO2, SERMO3: MA04-1
SP-R, SP-R1, SP-R2, SP-R3: 330; R0805
SV1, SV2, SV3, SV4, SV5, SV6, SV7, SV8: MA08-1
U$1, U$2, U$3, U$4, U$12, U$14, U$16, U$18, U$20, U$22, U$24, U$26: EAGLE-PLC-8MM
U$11, U$13, U$15, U$17, U$19, U$21, U$23, U$25: S9706

Connections:
+3V1: SERMO1.1, SV4.1
+3V2: SERMO2.1, SV6.1
+3V3: SERMO.1, SV2.1
+3V4: SERMO3.1, SV8.1
+3V7: CN9.1, U$11.VDD
+3V8: CN10.1, U$21.VDD
+3V9: CN5.1, U$13.VDD
+3V10: CN6.1, U$15.VDD
+3V11: CN7.1, U$17.VDD
+3V12: CN8.1, U$19.VDD
+3V13: CN11.1, U$23.VDD
+3V14: CN12.1, U$25.VDD
+5V: L1.A, S1.3, SV1.2
+5V1: L3.A, S2.3, SV3.2
+5V2: L5.A, S3.3, SV5.2
+5V3: L7.A, S4.3, SV7.2
+5V6: CN9.7, LED9.4
+5V7: CN10.7, LED10.4
+5V8: CN5.7, LED5.4
+5V9: CN6.7, LED6.4
+5V10: CN7.7, LED7.4
+5V11: CN8.7, LED8.4
+5V12: CN11.7, LED11.4
+5V13: CN12.7, LED12.4
CK4: CN5.5, U$13.CK
CK5: CN6.5, U$15.CK
CK6: CN7.5, U$17.CK
CK7: CN8.5, U$19.CK
CK8: CN9.5, U$11.CK
CK9: CN10.5, U$21.CK
CK10: CN11.5, U$23.CK
CK11: CN12.5, U$25.CK
DOUT4: CN5.3, U$13.DOUT
DOUT5: CN6.3, U$15.DOUT
DOUT6: CN7.3, U$17.DOUT
DOUT7: CN8.3, U$19.DOUT
DOUT8: CN9.3, U$11.DOUT
DOUT9: CN10.3, U$21.DOUT
DOUT10: CN11.3, U$23.DOUT
DOUT11: CN12.3, U$25.DOUT
GATE4: CN5.4, U$13.GATE
GATE5: CN6.4, U$15.GATE
GATE6: CN7.4, U$17.GATE
GATE7: CN8.4, U$19.GATE
GATE8: CN9.4, U$11.GATE
GATE9: CN10.4, U$21.GATE
GATE10: CN11.4, U$23.GATE
GATE11: CN12.4, U$25.GATE
GND: LED-R.1, MV1.7, SERMO.2, SP-R.1, SV1.1
GND1: LED-R1.1, MV2.7, SERMO1.2, SP-R1.1, SV3.1
GND2: LED-R2.1, MV3.7, SERMO2.2, SP-R2.1, SV5.1
GND3: LED-R3.1, MV4.7, SERMO3.2, SP-R3.1, SV7.1
GND6: CN9.2, R25.1, R26.1, R27.1, U$11.GND
GND7: CN10.2, R28.1, R29.1, R30.1, U$21.GND
GND8: CN5.2, R13.1, R14.1, R15.1, U$13.GND
GND9: CN6.2, R16.1, R17.1, R18.1, U$15.GND
GND10: CN7.2, R19.1, R20.1, R21.1, U$17.GND
GND11: CN8.2, R22.1, R23.1, R24.1, U$19.GND
GND12: CN11.2, R31.1, R32.1, R33.1, U$23.GND
GND13: CN12.2, R34.1, R35.1, R36.1, U$25.GND
MISOD: MV1.3, SV2.7
MISOD1: MV2.3, SV4.7
MISOD2: MV3.3, SV6.7
MISOD3: MV4.3, SV8.7
MOSID: MV1.2, SV2.8
MOSID1: MV2.2, SV4.8
MOSID2: MV3.2, SV6.8
MOSID3: MV4.2, SV8.8
MV: MV1.1, SV1.5
MV1: MV2.1, SV3.5
MV2: MV3.1, SV5.5
MV3: MV4.1, SV7.5
MVS: MV1.5, SV2.5
MVS1: MV2.5, SV4.5
MVS2: MV3.5, SV6.5
MVS3: MV4.5, SV8.5
unnamed: MV1.6, S1.2
unnamed: L2.C, LED-R.2
unnamed: MV2.6, S2.2
unnamed: L3.C, SP-R1.2
unnamed: L4.C, LED-R1.2
unnamed: MV3.6, S3.2
unnamed: L5.C, SP-R2.2
unnamed: L6.C, LED-R2.2
unnamed: MV4.6, S4.2
unnamed: L7.C, SP-R3.2
unnamed: L8.C, LED-R3.2
unnamed: LED9.2, R25.2
unnamed: LED9.3, R26.2
unnamed: LED9.1, R27.2
unnamed: LED10.2, R28.2
unnamed: LED5.2, R13.2
unnamed: LED5.3, R14.2
unnamed: LED5.1, R15.2
unnamed: LED6.2, R16.2
unnamed: LED6.3, R17.2
unnamed: LED6.1, R18.2
unnamed: LED7.2, R19.2
unnamed: LED7.3, R20.2
unnamed: L1.C, SP-R.2
unnamed: LED7.1, R21.2
unnamed: LED8.2, R22.2
unnamed: LED8.3, R23.2
unnamed: LED8.1, R24.2
unnamed: LED10.3, R29.2
unnamed: LED10.1, R30.2
unnamed: LED11.2, R31.2
unnamed: LED11.3, R32.2
unnamed: LED11.1, R33.2
unnamed: LED12.2, R34.2
unnamed: LED12.3, R35.2
unnamed: LED12.1, R36.2
P1: L4.A, SV3.4
P3: SERMO1.3, SV4.4
P4: SERMO.3, SV2.4
P5: SERMO.4, SV2.3
P8: L2.A, SV1.4
P9: SERMO1.4, SV4.3
P11: L6.A, SV5.4
P13: SERMO2.3, SV6.4
P14: SERMO2.4, SV6.3
P16: L8.A, SV7.4
P18: SERMO3.3, SV8.4
P19: SERMO3.4, SV8.3
RANGE4: CN5.6, U$13.RANGE
RANGE5: CN6.6, U$15.RANGE
RANGE6: CN7.6, U$17.RANGE
RANGE7: CN8.6, U$19.RANGE
RANGE8: CN9.6, U$11.RANGE
RANGE9: CN10.6, U$21.RANGE
RANGE10: CN11.6, U$23.RANGE
RANGE11: CN12.6, U$25.RANGE
SCKD: MV1.4, SV2.6
SCKD1: MV2.4, SV4.6
SCKD2: MV3.4, SV6.6
SCKD3: MV4.4, SV8.6
