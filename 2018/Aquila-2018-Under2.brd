# Repository rakuseirobot/Aquila-PCB (continued)

## EAGLE design 2018/TEPIAmainboard.brd (continued)

Board: 2 copper layers, 128.7 x 99.3 mm, 110 parts (17 on the bottom side), 106 nets.

## EAGLE design 2018/Aquila-2018 - コピー.brd

Parts:
3.3C1, 5C1, 9C1: 100u; E2,5-6
3.3C2, 5C2, 9C2: 0.1u; C0805
3.3REG, 5VREG: OKL-T_6-W12N-C; OKL-T/3-W5
C1, C3: 22uF25V; C2012
C2, C4: 10uF10V; C2012
CHECKLED: OSTA71A1D-A
ERROR1-R, ERROR2-R: 330; R0805
FT232-R8, FT232-R9: 330; R0805
FT232-R10: 4.7K; R0805
FT232-R11: 10K; R0805
FT232-R12: 1K; R0805
FT232-R13, FT232-R14: 23; R0805
FT232USBCON: Wrie-USB; 32005-201
FT-POWERLED: LEDCHIPLED_0805; CHIPLED_0805
GND-CH: SMD5; SMD2,54-5,08
GND-CHK, GND-CHK1: 2,15/1,0
I2C-R: XH-4; CON4
IC1: FT232RL; SSOP28
IC2: ULN2003AN; DIL16
INDILED1, INDILED2, INDILED3, INDILED4: 330; R0805
J1: XH-5; CON5
JTAG: 20021221-00010C4LF
L3: E1; LED5MM
L4: E2; LED5MM
L5: RXDLED; CHIPLED_0805
L6: TXDLED; CHIPLED_0805
LCD: C2; MA05-1
M1-R1, M2-R1: 4.7K; R0805
M-SW: TL36PO; TL3XPO
MAIN-SPL: XH-2; CON2
MAINSW2: MA03-1
MEGA1, MEGA2: MEGA8-AI; TQFP32-08
MEGA1-C1, MEGA2-C1: 0.1u; C0805
MOTORDRIVER: ML14
MPU: XH-4; CON4
Q1, Q2: 20MHz; CSTLS_X
Q3, Q4, Q5: IRF9530; TO220BV
R1, R2: 1.2k; 0204/7
R-B: ?; R0805
R-G: ?; R0805
R-R: ?; R0805
RESET-MEGA1: R-1; DTS-6
RESET-MEGA2: R-2; DTS-6
RESET-XMEGA: DTS-6
S1: DIP08S
S2: M251
SG1: F/EE17P
SL-R1: 1K; R0805
SP-LED: LEDCHIPLED_0805; CHIPLED_0805
SP-R1, SP-R3: 1.2k; R0805
SP-R2, SP-R4: 20K; R0805
SP-R5, SP-R6: 4.7K; R0805
SP-RC1, SP-RC2: 20k; RTRIM3296W
SP-SW2: 219-02; CTS-219-02
SPI-R: XH-6; CON6
SPI-SW: DIP03YL
SRAM-R1: 4.7K; R0805
SRAM-R2: 10k; R0805
SS-R1, SS-R2: 4.7K; R0805
STEPINDI1, STEPINDI2, STEPINDI3: LED; CHIPLED_0805
STEPINDI4: KED; CHIPLED_0805
SUOPPLY-SW2: XH-3; CON3
SUPPLY3.3V, SUPPLY5V, SUPPLY9: MAIN; AK500/2
SV1: ML6
TESTSW-R1, TESTSW-R2, TESTSW-R3: 4.7K; R0805
TO-UNDER: ML26
TOUCH1, TOUCH2: XH-3; CON3
TW-SP: XH-2; CON2
TWILITE: C2; MA05-1
U1: ATXMEGA128A1U-AU; TQFP-100A-100
U2: 23K256-I/SN; SOIC127P600X175-8N
U$2: 5566-04A
VOLTAGE-METER1, VOLTAGE-METER2: XH-2; CON2
X2: DCJACK-MJ179P; MJ-179P
X-R1, X-R2: 4.7K; R0805
XMEGA-C1, XMEGA-C2: 0.1u; C0805
XMEGA-TEST1: SW1; DTS-6
XMEGA-TEST2: SW2; DTS-6
XMEGA-TEST3: SW3; DTS-6

Connections:
+3V3: 3.3C1.+, 3.3C2.1, 3.3REG.4 (VOUT), 3.3REG.5 (SENSE), C4.1, CHECKLED.ANODE, I2C-R.P$3 (3), JTAG.4, LCD.1, M1-R1.2, M2-R1.2, MEGA1.4 (VCC), MEGA1.6 (VCC), MEGA1.18 (AVCC), MEGA1.20 (AREF), MEGA1-C1.1, MEGA2.4 (VCC), MEGA2.6 (VCC), MEGA2.18 (AVCC), MEGA2.20 (AREF), MEGA2-C1.2, MOTORDRIVER.11, MPU.P$4 (4), R2.1, S2.1 (O), SPI-R.P$1 (1), SRAM-R1.2, SRAM-R2.2, SS-R1.2, SS-R2.2, SUPPLY3.3V.1, SV1.2, TO-UNDER.24, TOUCH1.P$2 (2), TOUCH2.P$2 (2), TW-SP.P$2 (2), U1.4 (AVCC), U1.14 (VCC), U1.24 (VCC), U1.34 (VCC), U1.44 (VCC), U1.54 (VCC), U1.64 (VCC), U1.74 (VCC), U1.83 (VCC), U1.94 (AVCC), U2.8 (VCC), U$2.4, X-R1.2, XMEGA-C1.1, XMEGA-C2.1, XMEGA-TEST1.1, XMEGA-TEST1.2, XMEGA-TEST2.1, XMEGA-TEST2.2, XMEGA-TEST3.1, XMEGA-TEST3.2
+5V: 5C1.+, 5C2.1, 5VREG.4 (VOUT), 5VREG.5 (SENSE), C2.1, IC2.9 (CD+), INDILED1.2, INDILED2.2, INDILED3.2, INDILED4.2, J1.P$1 (1), R1.1, S2.3 (S), SP-LED.A, SUPPLY5V.1, U$2.3
+9V: 3.3REG.2 (VIN), 5VREG.2 (VIN), 9C1.+, 9C2.1, C1.1, C3.1, MAIN-SPL.P$1 (1), Q4.S, Q5.D, SP-R2.2, SP-R4.2, SP-R5.2, VOLTAGE-METER1.P$1 (1)
CK: TO-UNDER.6, U1.46 (PF1)
CS: SRAM-R1.1, U1.82 (PK7), U2.1 (~CS)
DOUT: TO-UNDER.4, U1.48 (PF3)
FT232-RXD: IC1.5 (RXD), L5.A, S1.10 (2), S1.12 (2), S1.14 (2), TWILITE.4
FT232-TXD: IC1.1 (TXD), L6.A, S1.9 (2), S1.11 (2), S1.13 (2), TWILITE.2
FT-POWERLED1: FT232-R12.2, FT-POWERLED.C
FT-RESET: IC1.6 (!RI), S1.15 (2), S1.16 (2)
GATE: TO-UNDER.5, U1.47 (PF2)
GND: 3.3C1.-, 3.3C2.2, 3.3REG.3 (GND_1), 3.3REG.7 (GND_2), 5C1.-, 5C2.2, 5VREG.3 (GND_1), 5VREG.7 (GND_2), 9C1.-, 9C2.2, C1.2, C2.2, C3.2, C4.2, ERROR1-R.1, ERROR2-R.1, FT232-R8.1, FT232-R9.1, FT232-R11.1, FT232-R12.1, FT232USBCON.5, FT232USBCON.M1 (S1), FT232USBCON.M2 (S2), FT232USBCON.M3 (S3), FT232USBCON.M4 (S4), GND-CH.1, GND-CHK.1, GND-CHK1.1, I2C-R.P$4 (4), IC1.7 (GND), IC1.18 (GND), IC1.21 (GND), IC1.25 (GND), IC1.26 (TEST), IC2.5 (I5), IC2.6 (I6), IC2.7 (I7), IC2.8 (GND), JTAG.2, JTAG.10, LCD.5, M-SW.3 (S), MAIN-SPL.P$2 (2), MAINSW2.2, MEGA1.3 (GND), MEGA1.5 (GND), MEGA1.21 (GND), MEGA1-C1.2, MEGA2.3 (GND), MEGA2.5 (GND), MEGA2.21 (GND), MEGA2-C1.1, MOTORDRIVER.13, MPU.P$1 (1), Q1.2 (VSS), Q2.2 (VSS), Q3.G, R1.2, R2.2, RESET-MEGA1.3, RESET-MEGA1.4, RESET-MEGA2.3, RESET-MEGA2.4, RESET-XMEGA.3, RESET-XMEGA.4, SG1.2, SL-R1.1, SP-R1.1, SP-R3.1, SP-SW2.3, SP-SW2.4, SPI-R.P$6 (6), SUOPPLY-SW2.P$2 (2), SUPPLY3.3V.2, SUPPLY5V.2, SUPPLY9.2, SV1.6, TESTSW-R1.1, TESTSW-R2.1, TESTSW-R3.1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
HOLD: SRAM-R2.1, U2.7 (~HOLD)
M1CS: MEGA1.25 (PC2(ADC2)), MOTORDRIVER.6
M1EN: MEGA1.28 (PC5(ADC5/SCL)), MOTORDRIVER.10
M1INA: MEGA1.27 (PC4(ADC4/SDA)), MOTORDRIVER.9
M1INB: MEGA1.26 (PC3(ADC3)), MOTORDRIVER.8
M1PWM: MEGA1.10 (PD6(AIN0)), MOTORDRIVER.7
M2CS: MEGA2.25 (PC2(ADC2)), MOTORDRIVER.1
M2EN: MEGA2.28 (PC5(ADC5/SCL)), MOTORDRIVER.5
M2INA: MEGA2.27 (PC4(ADC4/SDA)), MOTORDRIVER.4
M2INB: MEGA2.26 (PC3(ADC3)), MOTORDRIVER.3
M2PWM: MEGA2.10 (PD6(AIN0)), MOTORDRIVER.2
MISO-M: IC1.11 (!CTS), MEGA1.16 (PB4(MISO)), MEGA2.16 (PB4(MISO)), SPI-SW.2
MISO-X: SPI-SW.5, U1.21 (PC6)
MISOD: TO-UNDER.15, U1.31 (PD6)
MISOF: SPI-R.P$4 (4), U1.51 (PF6), U2.2 (SO)
MOSI-M: IC1.10 (!DCD), MEGA1.15 (PB3(MOSI/OC2)), MEGA2.15 (PB3(MOSI/OC2)), SPI-SW.3
MOSI-X: SPI-SW.4, U1.20 (PC5)
MOSID: TO-UNDER.16, U1.30 (PD5)
MOSIF: SPI-R.P$3 (3), U1.50 (PF5), U2.5 (SI)
MV1: TO-UNDER.19, U1.27 (PD2)
MV2: TO-UNDER.18, U1.28 (PD3)
MV3: TO-UNDER.17, U1.29 (PD4)
MVS1: TO-UNDER.1, U1.70 (PJ5)
MVS2: TO-UNDER.2, U1.71 (PJ6)
MVS3: TO-UNDER.3, U1.72 (PJ7)
unnamed: IC2.4 (I4), U1.75 (PK0)
unnamed: SP-R1.2, SP-RC1.1 (A), SP-RC1.2 (S)
unnamed: IC2.3 (I3), U1.76 (PK1)
unnamed: Q3.S, Q5.S, SP-R6.2
unnamed: Q4.D, U$2.1
unnamed: SP-R3.2, SP-RC2.1 (A), SP-RC2.2 (S)
unnamed: M-SW.2, Q4.G
unnamed: 5VREG.6 (TRIM), SP-RC1.3 (E)
unnamed: M-SW.1 (O), SP-R5.1
unnamed: S2.2, VOLTAGE-METER2.P$1 (1)
unnamed: IC2.2 (I2), U1.77 (PK2)
unnamed: 3.3REG.6 (TRIM), SP-RC2.3 (E)
unnamed: IC2.1 (I1), U1.78 (PK3)
unnamed: 3.3REG.1 (ON/OFF), SP-R4.1, SP-SW2.2
unnamed: IC2.16 (O1), J1.P$2 (2), STEPINDI1.C
unnamed: IC2.15 (O2), J1.P$3 (3), STEPINDI2.C
unnamed: IC2.14 (O3), J1.P$4 (4), STEPINDI3.C
unnamed: IC2.13 (O4), J1.P$5 (5), STEPINDI4.C
unnamed: INDILED4.1, STEPINDI4.A
unnamed: INDILED3.1, STEPINDI3.A
unnamed: INDILED2.1, STEPINDI2.A
unnamed: INDILED1.1, STEPINDI1.A
unnamed: SL-R1.2, SP-LED.C
unnamed: 5VREG.1 (ON/OFF), SP-R2.1, SP-SW2.1
unnamed: MEGA2.7 (PB6(XTAL1/TOSC1)), Q2.1
unnamed: MEGA2.8 (PB7(XTAL2/TOSC2)), Q2.3
unnamed: MEGA1.7 (PB6(XTAL1/TOSC1)), Q1.1
unnamed: MEGA1.8 (PB7(XTAL2/TOSC2)), Q1.3
unnamed: Q3.D, SUPPLY9.1, X2.1
unnamed: MAINSW2.1, Q5.G, SP-R6.1, SUOPPLY-SW2.P$1 (1)
unnamed: FT232-R9.2, L5.C
unnamed: FT232-R8.2, L6.C
unnamed: FT232-R14.2, FT232USBCON.2
unnamed: FT232-R10.2, FT232USBCON.1, FT-POWERLED.A, IC1.20 (VCC)
unnamed: ERROR1-R.2, L3.K (C)
unnamed: ERROR2-R.2, L4.K (C)
unnamed: FT232-R10.1, FT232-R11.2, IC1.19 (!RESET)
unnamed: FT232-R13.2, FT232USBCON.3
unnamed: FT232-R13.1, IC1.15 (USBDP)
unnamed: FT232-R14.1, IC1.16 (USBDM)
unnamed: IC1.4 (VCCIO), IC1.17 (3V3OUT)
unnamed: CHECKLED.RED, R-R.2
unnamed: CHECKLED.GREEN, R-G.2
unnamed: CHECKLED.BLUE, R-B.2
unnamed: SV1.1, U1.89 (PDI)
PA0: SG1.1, U1.95 (PA0), X-R2.2
PH0: TESTSW-R1.2, U1.55 (PH0), XMEGA-TEST1.3, XMEGA-TEST1.4
PH1: TESTSW-R2.2, U1.56 (PH1), XMEGA-TEST2.3, XMEGA-TEST2.4
PH2: TESTSW-R3.2, U1.57 (PH2), XMEGA-TEST3.3, XMEGA-TEST3.4
PING1: TO-UNDER.13, U1.35 (PE0)
PING2: TO-UNDER.12, U1.36 (PE1)
PING3: TO-UNDER.11, U1.37 (PE2)
PING4: TO-UNDER.10, U1.38 (PE3)
PING5: TO-UNDER.9, U1.39 (PE4)
PING6: TO-UNDER.8, U1.40 (PE5)
PJ0: TOUCH1.P$1 (1), U1.65 (PJ0)
PJ1: TOUCH2.P$1 (1), U1.66 (PJ1)
PK4: L3.A, U1.79 (PK4)
PK5: L4.A, U1.80 (PK5)
PQ0: R-R.1, U1.85 (PQ0)
PQ1: R-G.1, U1.86 (PQ1)
PQ2: R-B.1, U1.87 (PQ2)
RANGE: TO-UNDER.7, U1.45 (PF0)
RESET-M1: M1-R1.1, MEGA1.29 (PC6(/RESET)), RESET-MEGA1.1, RESET-MEGA1.2, S1.1
RESET-M2: M2-R1.1, MEGA2.29 (PC6(/RESET)), RESET-MEGA2.1, RESET-MEGA2.2, S1.2 (1)
RO1: MEGA1.32 (PD2(INT0)), TO-UNDER.25
RO2: MEGA2.32 (PD2(INT0)), TO-UNDER.26
RXDM1: MEGA1.30 (PD0(RXD)), S1.6 (1)
RXDM2: MEGA2.30 (PD0(RXD)), S1.4 (1)
RXDX1: S1.8 (1), U1.17 (PC2)
SCK-M: IC1.9 (!DSR), MEGA1.17 (PB5(SCK)), MEGA2.17 (PB5(SCK)), SPI-SW.1
SCK-X: SPI-SW.6, U1.22 (PC7)
SCKD: TO-UNDER.14, U1.32 (PD7)
SCKF: SPI-R.P$2 (2), U1.52 (PF7), U2.6 (SCK)
SCL-C: I2C-R.P$1 (1), MPU.P$2 (2), U1.16 (PC1)
SCL-D: LCD.3, TO-UNDER.20, U1.26 (PD1)
SDA-C: I2C-R.P$2 (2), MPU.P$3 (3), U1.15 (PC0)
SDA-D: LCD.4, TO-UNDER.21, U1.25 (PD0)
SIG1: MEGA1.1 (PD3(INT1)), U1.5 (PB0)
SIG2: MEGA2.1 (PD3(INT1)), U1.6 (PB1)
SS1: MEGA1.14 (PB2(SS/OC1B)), SS-R1.1, U1.7 (PB2)
SS2: MEGA2.14 (PB2(SS/OC1B)), SS-R2.1, U1.8 (PB3)
SS-R: SPI-R.P$5 (5), U1.49 (PF4)
TCK: JTAG.1, U1.11 (PB6)
TDI: JTAG.9, U1.10 (PB5)
TDO: JTAG.3, U1.12 (PB7)
TMS: JTAG.5, U1.9 (PB4)
TXDM1: MEGA1.31 (PD1(TXD)), S1.5 (1)
TXDM2: MEGA2.31 (PD1(TXD)), S1.3 (1)
TXDX1: S1.7 (1), U1.18 (PC3)
X-RESET: JTAG.6, LCD.2, RESET-XMEGA.1, RESET-XMEGA.2, SV1.5, U1.90 (!RESET!/PDI), X-R1.1

Notes on the sheet:
MOTOR-AREA
SWITCHING-SWITCH
FT232RL
CHECK-LED
Xmega-TESTSW
TOUCH
Buzzer
ERROR-LEDs
電源ピン (予備電源含)

Board: 2 copper layers, 99.0 x 98.7 mm, 115 parts (17 on the bottom side), 128 nets.

## EAGLE design 2018/OpenMV-Shield-DESKTOP-QOJ183D.brd

Parts:
L1: SP-L; CHIPLED_0805
L2: LED; CHIPLED_0805
LED-R: 330; R0805
MV1: B7B-ZR
SERMO: MA04-1
SP-R: 330; R0805
SV1, SV2: MA08-1
SW: MA03-1

Connections:
+3V3: SERMO.1, SV2.1
+5V: L1.A, SV1.2, SW.3
BOOT: SV1.7
GND: LED-R.1, MV1.7, SERMO.2, SP-R.1, SV1.1
MISOD: MV1.3, SV2.7
MOSID: MV1.2, SV2.8
MV: MV1.1, SV1.5
MVS: MV1.5, SV2.5
unnamed: MV1.6, SW.2
unnamed: L2.C, LED-R.2
unnamed: L1.C, SP-R.2
P4: SERMO.3, SV2.4
P5: SERMO.4, SV2.3
P6: SV2.2
P7: SV1.3
P8: L2.A, SV1.4
RST: SV1.8
SCKD: MV1.4, SV2.6
SYN: SV1.6

Notes on the sheet:
P0:PB15/MOSI P1:PB14/MISO P2:PB13/SCLK P3:PB12/SS P4:PB10/TXD/SCL P5:PB11/RXD/SDA P6:PA5/ADC/DAC P7:PD12/SERVO1 P8:PD13/SERVO2 P9:PD14/SERVO3
